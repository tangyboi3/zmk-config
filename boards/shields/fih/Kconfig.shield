## boards/shields/fih/Kconfig.shield
```kconfig
config SHIELD_FIH_LEFT
    def_bool $(shields_list_contains,fih_left)

config SHIELD_FIH_RIGHT
    def_bool $(shields_list_contains,fih_right)
```
